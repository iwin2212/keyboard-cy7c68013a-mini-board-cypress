# Keil uVision project ezcombo.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0xE000-0xE3FF) CLOCK(48000000) MODDP2
  output: ezcombo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: USBJmpTb.OBJ EZUSB.LIB hid.c DSCR.A51 FW.C
